# Keil uVision project BI_Fly.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BI_Fly +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DTU;..\HARDWARE\IMU;..\HARDWARE\MPU6050;..\HARDWARE\UARTs;..\HARDWARE;..\HARDWARE\IIC;..\HARDWARE\EEPROM;..\HARDWARE\BaseTimer;..\HARDWARE\NRF24L01;..\nrf_protocol;..\HARDWARE\SPI;..\HARDWARE\Motor;..\nrf_protocol;..\PID;..\TASK
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c upload_state_machine.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/DTU/: DTU.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/UARTs/: UARTs.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/IMU/: IMU.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/BaseTimer/: base_timer_wrapper.c base_timer.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
  group nrf_protocol
    ../nrf_protocol/: nrf_protocol_variable.c nrf_protocol.c
  group PID
    ../PID/: IncPID.c attitude_pid.c
  group TASK
    ../TASK/: task.c
